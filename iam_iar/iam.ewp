# IAR project iam.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2617 MSP430F2617
  General.GStackSize2: 5300
  General.GHeapSize2: 0
  ICC430.CCDefines: BOARD=IAMREV1; KBD_INVERSE
  ICC430.newCCIncludePaths: src\; ..\inc\; ..\lib\vcl\; ..\lib\fs\; ..\lib\fs\inc\; ..\src\; ..\src\timeslot\
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: src\app.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../src/: ADC.c design.c KBD.c LCD.c main.c pool.c rtc.c ts_func.c ts_option.c ts_r.c utils.c
    src/: disk_sd.c ds1390.c ds3234.c flash.c hardware.c
    ../src/timeslot/: timeslot.c
  group FS/EFS
    ../lib/fs/: debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group FS/Interface
    ../lib/fs/interfaces/: msp2617_sd.c sd.c
  group VCL/SRC
    ../lib/vcl/: dispatch.c vcl.c
